# Repository DH2LM/AIOC

## KiCad design kicad/k1-aioc/k1-aioc.kicad_pcb

Parts:
C1, C2: 22p/NP0; C_0603_1608Metric; LCSC C1653
C4, C5, C6, C7, C10, C13, C14: 4.7u/10V/X5R; C_0603_1608Metric; LCSC C19666
C8, C9, C12, C15: 100n; C_0603_1608Metric; LCSC C14663
C11: 10n/NP0; C_0603_1608Metric; LCSC C57112
D1: GREEN; LED_0603_1608Metric; LCSC C72043
D2: RED; LED_0603_1608Metric; LCSC C2286
D3, D4: N.M.; LED_0603_1608Metric
FB1, FB2: 600R@100MHz; L_0603_1608Metric; LCSC C1002
H1, H2: ToolingHole; TOOLING-HOLE
J1: GT-USB-7010ASV; USB_C_Receptacle_G-Switch_GT-USB-7010ASV; LCSC C464604
J2: Conn_01x07_Male; PinHeader_1x07_P1.27mm_Vertical
Q1: BC847BS; SOT-363_SC-70-6; LCSC C8653
R1: 1.5K; R_0603_1608Metric; LCSC C22843
R2: 10K; R_0603_1608Metric; LCSC C25804
R3, R6, R7, R16: 5.1K; R_0603_1608Metric; LCSC C23186
R4, R8, R9, R15: 220R; R_0603_1608Metric; LCSC C22962
R5, R10, R11, R14: 2.2K; R_0603_1608Metric; LCSC C4190
R12, R13: 22R; R_0603_1608Metric; LCSC C23345
R17: N.M.; R_0603_1608Metric
U1: VRD3333; LLP-6 (2x1.8); LCSC C144168
U2: STM32F373CBTx; LQFP-48_7x7mm_P0.5mm; LCSC C94046
Y1: 8MHz/20pF; Crystal_SMD_5032-2Pin_5.0x3.2mm; LCSC C115962

Connections:
+3.3VA: C9.1, C10.1, FB1.1, R16.1, U2.9 (VDDA), U2.24 (VDDSD), U2.25 (VREFSD+)
+3V3: C4.1, C7.1, C8.1, J2.7, R1.1, U1.5 (VOUT1), U2.1 (VBAT), U2.17 (VDD), U2.36 (PF7), U2.48 (VDD)
/AFIN: C11.1, R3.2, R5.1, R16.2, U2.20 (PB2)
/AFOUT: R2.2, U2.14 (PA4)
/BOOT0: J2.1, R14.2, U2.44 (BOOT0)
/DAC_ATTEN: R17.2, U2.13 (PA3)
/NRST: C15.1, J2.3, U2.7 (NRST)
/OSCIN: C1.1, U2.5 (PF0), Y1.1
/OSCOUT: C2.1, U2.6 (PF1), Y1.2
/PTT1: R11.1, U2.11 (PA1)
/PTT2: R10.1, U2.10 (PA0)
/RADIO-MIC: C13.2
/RADIO-RX-PTT1: R8.1, R13.1
/RADIO-SPK: C14.2
/RADIO-TX: R9.1
/RADIO-VP-PTT2: R12.1
/SWCLK: J2.6, U2.37 (PA14)
/SWDIO: J2.4, U2.34 (PA13)
/SWO: J2.2, U2.39 (PB3)
/USART-RX: R9.2, U2.31 (PA10)
/USART-TX: R8.2, U2.30 (PA9)
/USB-DN: J1.A7 (D-), J1.B7 (D-), U2.32 (PA11)
/USB-DP: J1.A6 (D+), J1.B6 (D+), R1.2, U2.33 (PA12)
/VBUS: FB2.2, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
/VIN: C6.1, FB2.1, U1.1 (EN2), U1.2 (VIN), U1.3 (EN1)
GND: C1.2, C2.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C15.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.5, Q1.1 (E1), Q1.4 (E2), R3.1, R4.1, R6.1, R7.1, R14.1, U1.0 (GND), U1.4 (GND), U2.8 (VSSA), U2.23 (VSSSD), U2.35 (PF6), U2.47 (VSS)
unnamed: C12.1, C13.1, R2.1, R4.2, R17.1
unnamed: C14.1, R5.2
unnamed: D1.2 (A), D2.1 (K), D3.2 (A), D4.1 (K), U2.46 (PB9)
unnamed: D1.1 (K), D2.2 (A), D3.1 (K), D4.2 (A), R15.1
unnamed: J1.A5 (CC1), R7.2
unnamed: J1.B5 (CC2), R6.2
unnamed: Q1.2 (B1), R10.2
unnamed: Q1.6 (C1), R12.2
unnamed: Q1.5 (B2), R11.2
unnamed: Q1.3 (C2), R13.2
unnamed: C5.1, FB1.2, U1.6 (VOUT2)
unnamed: R15.2, U2.45 (PB8)

Notes on the sheet:
STM Disco SWD Header
Short Pins for Bootloader
SDADC1_AIN4P/ADC2_IN12
USART1-TX
K connector consists of two TRS connectors (3.5mm and 2.5mm) spaced 12mm apart Upper connector (2.5mm) T: SPK+ R: TxData (from Radio) S: GND Lower connector (3.5mm) T: +V/PTT2 R: MIC+ S: PTT1/RxData (to Radio)
GPIOA P.P.
DAC1_OUT1
GPIOA O.D.
Compatible to STM32F302CBTx (no DS-ADC)
USART1-RX

Board: 2 copper layers, 21.0 x 31.5 mm, 45 parts (2 on the bottom side), 34 nets.

File kicad/k1-aioc/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2",0603,2,22p/NP0,C1653
"C10, C13, C14, C4, C5, C6, C7",0603,7,4.7u/10V/X5R,C19666
C11,0603,1,10n/NP0,C57112
"C12, C15, C8, C9",0603,4,100n,C14663
D1,0603,1,GREEN,C72043
D2,0603,1,RED,C2286
"D3, D4, R17",0603,3,N.M.,
"FB1, FB2",0603,2,600R@100MHz,C1002
J1,USB_C_Receptacle_G-Switch_GT-USB-7010ASV,1,GT-USB-7010ASV,C464604
J2,PinHeader_1x07_P1.27mm_Vertical,1,Conn_01x07_Male,
Q1,SOT-363_SC-70-6,1,BC847BS,C8653
R1,0603,1,1.5K,C22843
"R10, R11, R14, R5",0603,4,2.2K,C4190
"R12, R13",0603,2,22R,C23345
"R15, R4, R8, R9",0603,4,220R,C22962
"R16, R3, R6, R7",0603,4,5.1K,C23186
R2,0603,1,10K,C25804
U1,LLP-6 (2x1.8),1,VRD3333,C144168
U2,LQFP-48_7x7mm_P0.5mm,1,STM32F373CBTx,C94046
Y1,Crystal_SMD_5032-2Pin_5.0x3.2mm,1,8MHz/20pF,C115962

## Commit log

2024-07-29 Made PCB a little bit more affordable
    Changed USB C Jack from Amphenol 12401832E402A to G-Switch GT-USB-7010ASV
    Changed LDO from MIC5330-SSYML-TR to VRD3333PLX
2024-07-29 Corrected silkscreen on bottom
2024-07-29 Changed designator of Type C Jack in Schematic
2024-08-12 Corrected LDO
2024-08-12 Corrected LDO again
2024-09-01 Added Cost reduced version
2024-09-05 Made DRC happy regarding errors
